# Keil uVision project cm0_keil1.uvprojx, settings and files
target uart_test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: cm0_keil1
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\bsp\CMSIS;.\bsp\device;.\drv;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group bsp
    ./bsp/device/: system_CMSDK_CM0.c startup_CMSDK_CM0.s
  group drv
    ./drv/: delay.c
  group src
    ./src/: int_handlers.c main.c scd.c scd_reg.c

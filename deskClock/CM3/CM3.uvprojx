# Keil uVision project CM3.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: CM3 +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L -c -d -e -s --output cm3.lst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o cm3.bin
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: .\CMSIS\Core\Include;.\CMSIS\Device\Include;.\CMSIS\Device\Source;.\CMSIS\Device\StdPeriph_Driver\inc;.\CMSIS\generic;.\driver;.\freertos;.\src
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./CMSIS/Device/Source/ARM/: startup_CM3DS.s
  group CMSIS
    ./CMSIS/Device/Source/: system_CM3DS.c
    ./CMSIS/Device/StdPeriph_Driver/src/: CM3DS_gpio.c CM3DS_rcc.c CM3DS_adc.c CM3DS_dma.c CM3DS_dualtimer.c CM3DS_exti.c CM3DS_i2c.c CM3DS_spi.c CM3DS_timer.c CM3DS_uart.c CM3DS_watchdog.c CM3DS_misc.c CM3_retarget.c
  group driver
    ./driver/: i2c_gpio.c lcd_9488_drv.c touch_GT911_drv.c i2c_gpio2.c thp_bme280_drv.c
  group freertos
    ./freertos/: event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group src
    ./src/: main.c delay.c scd.c scd_reg.c int_handlers.c
